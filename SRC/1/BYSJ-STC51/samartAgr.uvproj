# Keil uVision project samartAgr.uvproj, settings and files
target samartAgr (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: samartAgr +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group msys
    ./src/: mysys.c tasklist.c agreement.c
  group bsp
    ./src/: io.c delay.c uart.c
  group user
    ./src/: main.c
  group device
    ./src/: DHT11.c LCD12864.c
