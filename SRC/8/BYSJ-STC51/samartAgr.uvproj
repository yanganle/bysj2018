# Keil uVision project samartAgr.uvproj, settings and files
target samartAgr (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: samartAgr +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group msys
    ./src/: mysys.c tasklist.c agreement.c
  group bsp
    ./src/: io.c delay.c uart.c uart2.c adc.c
  group user
    ./src/: main.c
  group device
    ./src/: TFT_LCD.c DS18B20.c
